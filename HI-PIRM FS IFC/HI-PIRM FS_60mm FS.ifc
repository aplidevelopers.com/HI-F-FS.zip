Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2017-02-23T17:52:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.2.0.0 - Alternate UI 17.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 23 17:52:31 2017 * Host: DESKTOP-CA24E47 * Database: C:\Users\PC002\AppData\Local\Temp\{32118D3E-9AD6-4241-8EC3-8198C8D77CAC}\ifc * Database version: 5507 * Database creation date: Thu Feb 23 17:52:30 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Feb 23 17:52:30 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 23 17:52:30 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 m
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 m
Dimensions - Computation Height: 0 m
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcCurtainWall: Curtain Wall:Curtain Wall, Curtain Wall:Curtain Wall:201474
In: Level 1
Type - Construction(Type) - Automatically Embed: no; Function: Exterior; Join Condition: Not Defined
Type - Horizontal Grid(Type) - Adjust for Mullion Size: no
Type - Identity Data(Type) - Type Name: Curtain Wall
Type - Other(Type) - Category: Walls; Family Name: Curtain Wall
Type - Vertical Grid(Type) - Adjust for Mullion Size: no
Pset_CurtainWallCommon - Reference: Curtain Wall; IsExternal: yes
Constraints - Base Constraint: Level: Level 1; Base is Attached: no; Base Offset: 0 m; Related to Mass: no; Room Bounding: yes; Top is Attached: no; Top Offset: 0 m; Unconnected Height: 8 m
Dimensions - Area: 20.8 m2; Length: 2.6 m
Horizontal Grid - Angle: 0 deg; Justification: Beginning; Number: 4; Offset: 0 m; sets with these values: 2
Other - Category: Walls; Family: Curtain Wall: Curtain Wall; Family and Type: Curtain Wall: Curtain Wall; Type: Curtain Wall: Curtain Wall; Type Id: Curtain Wall: Curtain Wall
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing

# IfcPlate: HI-PIRM F 60, HI- PIRM FS:60 mm:201475
In: Level 1
Type - ElementType: 60 mm; PredefinedType: CURTAIN_PANEL; Material: Por defecto Nuevo material, Huurre_Panel
Type - Analytical Properties(Type) - Analytic Construction: <None>
Type - Dimensions(Type) - A': 0.03 m; A-23.25: 0.03625 m; CoreInsulationDepth: 0.06 m; OverallThickness: 0.06 m
Type - Energy Analysis(Type) - R: 2.55; U-Value: 0.38
Type - Identity Data(Type) - Manufacturer: HUURRE IBÉRICA S.A.; OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Name: 60 mm; URL: www.huurreiberica.com
Type - Materials and Finishes(Type) - Finish: E5001 / Poliéster 25micras / HDX 55 micras / HDS 35 micras / PVDF 35 micras / PET 50 micras / INOX; PanelMaterial: Huurre_Panel
Type - Other(Type) - Category: Curtain Panels; Ancho: 1.15 m; Aplicación: Cámaras frigoríficas; Características Medioambientales: Libre de SVHC Sustancias extremadamente preocupantes de acuerdo con requisitos de REACH. Proceso de fabricación sin liberación de gases tipo HCFCs.; Certificados: Marcado CE, Marca N (AENOR), FM Global 4880 y 4881, DTA y Acermi (CSTB); Color de acabado: www.huurreiberica.com/docs/HUURRE-CARTA-COLORES.pdf; Comportamiento frente al fuego: Euroclase B,s1,d0; Densidad nominal núcleo aislante: 40 kg/m3; Family Name: HI- PIRM FS; Ficha técnica del producto: www.huurreiberica.com/index.php/es/paneles-frigorificos/hi-f-frigorifico; Fijaciones: Varillas roscadas con remates chinos; Garantía: Hasta 25 años prestaciones funcionales, hasta 35 años para sus recubrimientos; Material cara exterior: Chapa perfilada de acero; Material cara interior: Chapa perfilada de acero; Material de Junta: Banda de polietileno de celda cerrada y densidad 33 kg/m3; Material núcleo aislante: Espuma PIRM HUURRE; Normas de referencia: UNE EN 14509 para paneles, UNE EN 10327 para recubrimiento galvanizado, UNE EN 10169 para recubrimientos orgánicos; Peso: 0.984772; Referencia de producto: HI-PIRM F 60; Suministrador: HUURRE IBÉRICA S.A.; Tipo de junta: Doble junta machihembrada tipo FS; Transmitancia térmica: 0.0217; Web del fabricante: www.huurreiberica.com
Constraints - Level: Level: Level 1
Dimensions - Area: 20.8 m2; Height: 8 m; Volume: 0.537138 m3; Width: 2.6 m
Other - Category: Curtain Panels; Family: HI- PIRM FS: 60 mm; Family and Type: HI- PIRM FS: 60 mm; Host Id: Curtain Wall: Curtain Wall; Type: HI- PIRM FS: 60 mm; Type Id: HI- PIRM FS: 60 mm
Phasing - Phase Created: New Construction
Pset_PlateCommon - IsExternal: yes; Reference: 60 mm; LoadBearing: yes
Pset_ManufacturerTypeInformation - Manufacturer: HUURRE IBÉRICA S.A.
